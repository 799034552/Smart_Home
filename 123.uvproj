# Keil uVision project 123.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 123 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User
  link misc: REMOVEUNUSED
  group main
    ./: main.c
  group User
    ./User/: uart.c iic.c env.c timer.c music.c key.c
